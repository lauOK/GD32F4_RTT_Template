# Keil uVision project GD32F407_Demo.uvprojx, settings and files
target GD32_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: .\Source\Firmware\CMSIS;.\Source\Firmware\CMSIS\GD\GD32F4xx\Include;.\Source\Firmware\GD32F4xx_standard_peripheral\Include;.\Source\User;.\Source\BSP;.\Source\RT-Thread\bsp;.\Source\RT-Thread\components\finsh;.\Source\RT-Thread\include;.\Source\RT-Thread\include\libc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Source/User/: gd32f4xx_it.c main.c systick.c
  group BSP
    ./Source/BSP/: led.c uart0.c
  group SDK
    ./Source/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./Source/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ./Source/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group RTOS
    ./Source/RT-Thread/bsp/: board.c rtconfig.h
    ./Source/RT-Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ./Source/RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ./Source/RT-Thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c finsh_config.h
